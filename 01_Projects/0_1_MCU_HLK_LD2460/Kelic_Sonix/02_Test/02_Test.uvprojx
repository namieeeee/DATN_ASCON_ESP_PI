# Keil uVision project 02_Test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: SN34F788F SONiX
  pack: SONiX.SN34F7_DFP.2.0.4
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x7DFFC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 02_Test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x7dffc
  memory RVCT9: RAM 0x20000000 size 0x28000
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.2
