# Keil uVision project ADEV.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SN34F788F SONiX
  pack: SONiX.SN34F7_DFP.2.0.4
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x7DFFC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 01_Test +hex
  AfterMake: D:\APP\kelic_8051\UV4\HexConvert.exe SN34F780 "#H" RW
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER
  c include: ..\..\Lib_HAL\Board;..\..\Lib_HAL\Com;..\..\Lib_HAL\Middlewares\Include;..\..\Lib_HAL\Peripherals\Include;.\include;.\LIB\hlk_ld2460;.\LIB\System;.\LIB\Main_task;.\LIB\Common;.\LIB\cbuffer;.\LIB\FPGA;.\LIB\control_led
  memory RVCT4: ROM 0x0 size 0x7dffc
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Users_App
    ./src/: main.c sn34f78x_it.c
  group bsp
    ./src/: init.c sn34f78x_hal_msp.c
    ./include/: init.h
  group config
    ./include/: sn34f78x_hal_conf.h
  group driver
    ../../Lib_HAL/Peripherals/Source/: sn34f78x_hal.c sn34f78x_hal_rcc.c sn34f78x_hal_gpio.c sn34f78x_hal_flash.c sn34f78x_hal_flash_ex.c sn34f78x_hal_systick.c sn34f78x_hal_assert.c sn34f78x_hal_scu.c sn34f78x_hal_uart.c sn34f78x_hal_uart.h sn34f78x_hal_tpm.c sn34f78x_hal_crc.c sn34f78x_hal_dma.c
  group main_task
    ./LIB/Common/: common.h common.c
    ./LIB/Main_task/: main_task.c main_task.h System_Management.c System_Management.h
  group module
    ./LIB/hlk_ld2460/: hlk_ld2460.c hlk_ld2460.h
  group cbuffer
    ./LIB/cbuffer/: cbuffer.c cbuffer.h
  group FPGA
    ./LIB/FPGA/: fpga.c fpga.h
  group Control_LED
    ./LIB/control_led/: control_led.c control_led.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.2
